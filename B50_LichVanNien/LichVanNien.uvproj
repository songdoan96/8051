# Keil uVision project LichVanNien.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LichVanNien +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../my_lib/: Delay.c LCD4.c LunarCalendar.c Rtc_Ds1307.c Soft_I2C.c
