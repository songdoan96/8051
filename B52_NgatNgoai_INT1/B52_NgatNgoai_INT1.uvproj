# Keil uVision project B52_NgatNgoai_INT1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: B52_NgatNgoai_INT1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../my_lib/: Delay.c LCD4.c Rtc_Ds1307.c LunarCalendar.c Soft_I2C.c
